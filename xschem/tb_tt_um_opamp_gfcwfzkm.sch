** sch_path: xschem/tb_tt_um_opamp_gfcwfzkm.sch
**.subckt tb_tt_um_opamp_gfcwfzkm
x1 VDIGITAL VANALOG INA startup net32 net33 net34 dac_disabl fol_disabl oa_disabl all_disabl net8
+ net9 net10 net31 D7 net30 D6 net29 D5 net28 D4 net27 D3 net26 D2 net25 D1 net24 D0 output oe_check net11
+ net23 net12 net22 net13 net21 net14 net20 net15 net19 net16 net18 SEL1 net17 SEL0 net7 net6 net5 net4 GND
+ net3 tt_um_opamp_gfcwfzkm
VSUPD net1 GND 1.2 pulse 0 1.2 100n 1u
Vidigital net1 VDIGITAL 0
.save i(vidigital)
VSUPA net36 GND 3.3 pulse 0 3.3 100ns 1u
Vianalog net36 VANALOG 0
.save i(vianalog)
VSIGNAL input net35 1.65 SIN 0 1 20k 1us
Visignal input net2 0
.save i(visignal)
R1 INA net2 50k m=1
C1 output GND 10p m=1
R2 INA output 50k m=1
R3 output GND 1Meg m=1
V1 D0 GND 0 pulse 0 1.2 187.5u 10n 10n 1u 2u
V2 D1 GND 0 pulse 0 1.2 187.5u 10n 10n 2u 4u
V3 D2 GND 0 pulse 0 1.2 187.5u 10n 10n 4u 8u
V4 D3 GND 0 pulse 0 1.2 187.5u 10n 10n 8u 16u
V5 D4 GND 0 pulse 0 1.2 187.5u 10n 10n 16u 32u
V6 D5 GND 0 pulse 0 1.2 187.5u 10n 10n 32u 64u
V7 D6 GND 0 pulse 0 1.2 187.5u 10n 10n 64u 128u
V8 D7 GND 0 pulse 0 1.2 187.5u 10n 10n 128u 256u
V9 SEL1 GND 0 pulse 0 1.2 125u 100n 100n 125u 250u
V10 SEL0 GND 0 pulse 0 1.2 62.5u 100n 100n 62.5u 125u
* noconn #net3
* noconn #net4
* noconn #net5
* noconn #net6
* noconn #net7
* noconn #net8
* noconn #net9
* noconn #net10
* noconn #net11
* noconn #net12
* noconn #net13
* noconn #net14
* noconn #net15
* noconn #net16
* noconn #net17
* noconn #net18
* noconn #net19
* noconn #net20
* noconn #net21
* noconn #net22
* noconn #net23
* noconn oe_check
* noconn #net24
* noconn #net25
* noconn #net26
* noconn #net27
* noconn #net28
* noconn #net29
* noconn #net30
* noconn #net31
* noconn #net34
* noconn #net33
* noconn #net32
Vturnon net35 GND 0 pulse 0 1.65 1.1us 100ns
**** begin user architecture code

.options savecurrents
.include tb_tt_um_opamp_gfcwfzkm.save
.control
  save all
  optran 1 1 1 10n 10u 0
  * Static Operation Point Analysis
  op
  let power_d=-V(VDIGITAL) * I(VSUPD)
  let power=-V(VANALOG) * I(VSUPA)
  settype power power
  write tb_tt_um_opamp_gfcwfzkm.raw
  set appendwrite
  * Transient Analysis
  * === NOTE ===
  * Set the time to 10u max if doing a power-up simulation!
  *tran 10n 1u
  tran 10n 250u
  let power_d=-V(VDIGITAL) * I(VSUPD)
  let power=-V(VANALOG) * I(VSUPA)
  settype power power
  write tb_tt_um_opamp_gfcwfzkm.raw
  exit
.endc



.lib cornerMOSlv.lib mos_tt
.lib cornerMOShv.lib mos_tt
.lib cornerRES.lib res_typ
.lib cornerCAP.lib cap_typ
.include sg13g2_bondpad.lib


**** end user architecture code
**.ends

* expanding   symbol:  tt_um_opamp_gfcwfzkm.sym # of pins=53
** sym_path: xschem/tt_um_opamp_gfcwfzkm.sym
** sch_path: xschem/tt_um_opamp_gfcwfzkm.sch
.subckt tt_um_opamp_gfcwfzkm VDPWR ua[0] ua[2] uo_out[7] uo_out[6] uo_out[5] uo_out[4] uo_out[3]
+ uo_out[2] uo_out[1] uo_out[0] clk ena rst_n uio_out[7] ui_in[7] uio_out[6] ui_in[6] uio_out[5] ui_in[5]
+ uio_out[4] ui_in[4] uio_out[3] ui_in[3] uio_out[2] ui_in[2] uio_out[1] ui_in[1] uio_out[0] ui_in[0] ua[1]
+ uio_oe[7] uio_in[7] uio_oe[6] uio_in[6] uio_oe[5] uio_in[5] uio_oe[4] uio_in[4] uio_oe[3] uio_in[3] uio_oe[2]
+ uio_in[2] uio_oe[1] uio_in[1] uio_oe[0] uio_in[0] ua[3] ua[4] ua[5] ua[6] VGND ua[7]
*.iopin VDPWR
*.ipin clk
*.opin uo_out[7]
*.iopin VGND
*.iopin ua[7]
*.iopin ua[6]
*.iopin ua[5]
*.iopin ua[4]
*.iopin ua[3]
*.iopin ua[0]
*.iopin ua[2]
*.iopin ua[1]
*.ipin ena
*.ipin rst_n
*.ipin ui_in[7]
*.ipin ui_in[6]
*.ipin ui_in[5]
*.ipin ui_in[4]
*.ipin ui_in[3]
*.ipin ui_in[2]
*.ipin ui_in[1]
*.ipin ui_in[0]
*.ipin uio_in[7]
*.ipin uio_in[6]
*.ipin uio_in[5]
*.ipin uio_in[4]
*.ipin uio_in[3]
*.ipin uio_in[2]
*.ipin uio_in[1]
*.ipin uio_in[0]
*.opin uo_out[6]
*.opin uo_out[5]
*.opin uo_out[4]
*.opin uo_out[3]
*.opin uo_out[2]
*.opin uo_out[1]
*.opin uo_out[0]
*.opin uio_oe[7]
*.opin uio_oe[6]
*.opin uio_oe[5]
*.opin uio_oe[4]
*.opin uio_oe[3]
*.opin uio_oe[2]
*.opin uio_oe[1]
*.opin uio_oe[0]
*.opin uio_out[7]
*.opin uio_out[6]
*.opin uio_out[5]
*.opin uio_out[4]
*.opin uio_out[3]
*.opin uio_out[2]
*.opin uio_out[1]
*.opin uio_out[0]
x1 ua[0] net2 ua[1] ua[1] ua[2] VGND DISABLE_FOLLOWER op_amp_ver_2
x2 ua[0] net1 ua[2] ua[1] RD_TAP VGND DISABLE_EXTFEEDBACK op_amp_ver_2
x3 ua[0] net1 net2 net3 PTAT_STARTUP VGND ptat_curr_gen
x4 ua[0] ua[1] RD_TAP net3 nD7 nD0 nD2 nD4 nD5 nD6 nD3 nD1 VGND DISABLE_DAC r2r_dac
x5 ua[0] RD_TAP VGND res_divider
x9 VDPWR uio_in[1] nSEL0 uio_in[0] nSEL1 nSEL2 nSEL3 VGND digital_decoder
x8 VDPWR ua[0] nD7 ui_in[7] nD6 ui_in[6] nD5 ui_in[5] nD4 ui_in[4] ui_in[3] nD3 ui_in[2] nD2 nD1
+ ui_in[1] ui_in[0] nD0 VGND 8x_inverting_digital_level_translator
x6 VDPWR ua[0] nSEL3 DISABLE_DAC nSEL2 DISABLE_FOLLOWER nSEL1 DISABLE_EXTFEEDBACK nSEL0 DISABLE_ALL
+ VGND 4x_digital_level_translator
x7 VDPWR uo_out[7] PTAT_STARTUP DISABLE_DAC uo_out[3] DISABLE_FOLLOWER uo_out[2] uo_out[1]
+ DISABLE_EXTFEEDBACK DISABLE_ALL uo_out[0] VGND 5x_down_digital_translator
* noconn clk
* noconn ena
* noconn rst_n
* noconn uio_in[7]
* noconn uio_in[6]
* noconn uio_in[5]
* noconn uio_in[4]
* noconn uio_in[3]
* noconn uio_in[2]
* noconn ua[3]
* noconn ua[4]
* noconn ua[5]
* noconn ua[6]
* noconn ua[7]
x10 VDPWR uo_out[6] VGND tie_low
x11 VDPWR uo_out[5] VGND tie_low
x12 VDPWR uo_out[4] VGND tie_low
x13 VDPWR uio_out[7] VGND tie_low
x14 VDPWR uio_out[6] VGND tie_low
x15 VDPWR uio_out[5] VGND tie_low
x16 VDPWR uio_out[4] VGND tie_low
x17 VDPWR uio_out[3] VGND tie_low
x18 VDPWR uio_out[2] VGND tie_low
x19 VDPWR uio_out[1] VGND tie_low
x20 VDPWR uio_out[0] VGND tie_low
x21 VDPWR uio_oe[7] VGND tie_low
x22 VDPWR uio_oe[6] VGND tie_low
x23 VDPWR uio_oe[5] VGND tie_low
x24 VDPWR uio_oe[4] VGND tie_low
x25 VDPWR uio_oe[3] VGND tie_low
x26 VDPWR uio_oe[2] VGND tie_low
x27 VDPWR uio_oe[1] VGND tie_low
x28 VDPWR uio_oe[0] VGND tie_low
XC1 ua[0] VGND cap_cmim w=20e-6 l=20e-6 m=42 mm_ok=1
XC2 VDPWR VGND cap_cmim w=100e-6 l=20e-6 m=1 mm_ok=1
XC3 RD_TAP VGND cap_cmim w=10e-6 l=70e-6 m=1 mm_ok=1
.ends


* expanding   symbol:  op_amp_ver_2.sym # of pins=7
** sym_path: xschem/op_amp_ver_2.sym
** sch_path: xschem/op_amp_ver_2.sch
.subckt op_amp_ver_2 POAVDD IOAIREF IOAM OOA IOAP POAVSS IOADISABLE
*.iopin POAVDD
*.ipin IOAM
*.ipin IOAP
*.opin OOA
*.ipin IOAIREF
*.iopin POAVSS
*.ipin IOADISABLE
XMP13 net1 net1 POAVDD POAVDD sg13_hv_pmos w=2.4u l=0.4u ng=1 m=1 mm_ok=1
XMP14 ptlg ptlg net1 POAVDD sg13_hv_pmos w=2.4u l=0.4u ng=1 m=1 mm_ok=1
XMN16 ptlg ncasc net2 POAVSS sg13_hv_nmos w=0.6u l=0.6u ng=1 m=1 mm_ok=1
XMN13 net2 nbias POAVSS POAVSS sg13_hv_nmos w=0.6u l=2.4u ng=1 m=1 mm_ok=1
XMN18 ntlg ntlg net3 POAVSS sg13_hv_nmos w=1.2u l=0.6u ng=1 m=1 mm_ok=1
XMN17 net3 net3 POAVSS POAVSS sg13_hv_nmos w=1.2u l=0.6u ng=1 m=1 mm_ok=1
XMP10 net11 pbias POAVDD POAVDD sg13_hv_pmos w=1.2u l=1.2u ng=1 m=1 mm_ok=1
XMP12 ntlg pcasc net11 POAVDD sg13_hv_pmos w=1.2u l=0.6u ng=1 m=1 mm_ok=1
XMP1 net9 pbias POAVDD POAVDD sg13_hv_pmos w=1.2u l=1.2u ng=1 m=4 mm_ok=1
XMP2 net10 pbias POAVDD POAVDD sg13_hv_pmos w=1.2u l=1.2u ng=1 m=4 mm_ok=1
XMN1 net9 IOAM net5 POAVSS sg13_hv_nmos w=4.8u l=0.45u ng=1 m=1 mm_ok=1
XMN2 net10 IOAP net5 POAVSS sg13_hv_nmos w=4.8u l=0.45u ng=1 m=1 mm_ok=1
XMN3 net4 nbias POAVSS POAVSS sg13_hv_nmos w=0.6u l=2.4u ng=1 m=8 mm_ok=1
XMN6 net5 ncasc net4 POAVSS sg13_hv_nmos w=0.6u l=0.6u ng=1 m=8 mm_ok=1
XMN7 net8 ncasc net7 POAVSS sg13_hv_nmos w=0.6u l=0.6u ng=1 m=8 mm_ok=1
XMN8 ndrive ncasc net6 POAVSS sg13_hv_nmos w=0.6u l=0.6u ng=1 m=8 mm_ok=1
XMN4 net7 net8 POAVSS POAVSS sg13_hv_nmos w=0.6u l=2.4u ng=1 m=8 mm_ok=1
XMN5 net6 net8 POAVSS POAVSS sg13_hv_nmos w=0.6u l=2.4u ng=1 m=8 mm_ok=1
XMP3 net9 pbias POAVDD POAVDD sg13_hv_pmos w=1.2u l=1.2u ng=1 m=4 mm_ok=1
XMP5 net8 pcasc net9 POAVDD sg13_hv_pmos w=1.2u l=0.6u ng=1 m=8 mm_ok=1
XMP4 net10 pbias POAVDD POAVDD sg13_hv_pmos w=1.2u l=1.2u ng=1 m=4 mm_ok=1
XMP6 pdrive pcasc net10 POAVDD sg13_hv_pmos w=1.2u l=0.6u ng=1 m=8 mm_ok=1
XMP7 ndrive ptlg pdrive POAVDD sg13_hv_pmos w=2.4u l=0.4u ng=1 m=4 mm_ok=1
XMN9 pdrive ntlg ndrive POAVSS sg13_hv_nmos w=1.2u l=0.6u ng=1 m=4 mm_ok=1
XMP8 OOA pdrive POAVDD POAVDD sg13_hv_pmos w=2.4u l=0.4u ng=1 m=40 mm_ok=1
XMN10 OOA ndrive POAVSS POAVSS sg13_hv_nmos w=1.2u l=0.6u ng=1 m=40 mm_ok=1
XC2 OOA ndrive cap_cmim w=28.570e-6 l=14e-6 m=1 mm_ok=1
XC1 OOA pdrive cap_cmim w=28.570e-6 l=14e-6 m=1 mm_ok=1
XMN20 IOAIREF IOAIREF POAVSS POAVSS sg13_hv_nmos w=0.6u l=2.4u ng=1 m=1 mm_ok=1
XMN21 pcasc IOAIREF POAVSS POAVSS sg13_hv_nmos w=0.6u l=2.4u ng=1 m=1 mm_ok=1
XMN22 pbias IOAIREF POAVSS POAVSS sg13_hv_nmos w=0.6u l=2.4u ng=1 m=1 mm_ok=1
XMN23 net19 ncasc POAVSS POAVSS sg13_hv_nmos w=0.4u l=10u ng=1 m=1 mm_ok=1
XMN25 net13 nbias POAVSS POAVSS sg13_hv_nmos w=0.6u l=2.4u ng=1 m=1 mm_ok=1
XMN24 ncasc ncasc net22 POAVSS sg13_hv_nmos w=0.4u l=10u ng=1 m=1 mm_ok=1
XMN26 nbias ncasc net13 POAVSS sg13_hv_nmos w=0.6u l=0.6u ng=1 m=1 mm_ok=1
XMP21 pcasc pcasc net18 POAVDD sg13_hv_pmos w=1u l=10u ng=1 m=1 mm_ok=1
XMP20 net18 pcasc net17 POAVDD sg13_hv_pmos w=1u l=10.0u ng=1 m=1 mm_ok=1
XMP22 net12 pbias POAVDD POAVDD sg13_hv_pmos w=1.2u l=1.2u ng=1 m=1 mm_ok=1
XMP25 pbias pcasc net12 POAVDD sg13_hv_pmos w=1.2u l=0.6u ng=1 m=1 mm_ok=1
XMP26 ncasc pcasc net15 POAVDD sg13_hv_pmos w=1.2u l=0.6u ng=1 m=1 mm_ok=1
XMP23 net15 pbias POAVDD POAVDD sg13_hv_pmos w=1.2u l=1.2u ng=1 m=1 mm_ok=1
XMP24 net14 pbias POAVDD POAVDD sg13_hv_pmos w=1.2u l=1.2u ng=1 m=1 mm_ok=1
XMP27 nbias pcasc net14 POAVDD sg13_hv_pmos w=1.2u l=0.6u ng=1 m=1 mm_ok=1
XMP16 net17 pcasc net16 POAVDD sg13_hv_pmos w=1u l=10.0u ng=1 m=1 mm_ok=1
XMN11 net20 ncasc net19 POAVSS sg13_hv_nmos w=0.4u l=10u ng=1 m=1 mm_ok=1
XMP28 net16 pcasc POAVDD POAVDD sg13_hv_pmos w=1u l=10.0u ng=1 m=1 mm_ok=1
XMN12 net21 ncasc net20 POAVSS sg13_hv_nmos w=0.4u l=10u ng=1 m=1 mm_ok=1
XMN14 net22 ncasc net21 POAVSS sg13_hv_nmos w=0.4u l=10u ng=1 m=1 mm_ok=1
XMDP1 POAVDD pbias POAVDD POAVDD sg13_hv_pmos w=1.2u l=1.2u ng=1 m=1 mm_ok=1
XMDP2 POAVDD pbias POAVDD POAVDD sg13_hv_pmos w=1.2u l=1.2u ng=1 m=1 mm_ok=1
XMDOP1 POAVDD pcasc POAVDD POAVDD sg13_hv_pmos w=1.2u l=0.6u ng=1 m=1 mm_ok=1
XMDOP2 POAVDD pcasc POAVDD POAVDD sg13_hv_pmos w=1.2u l=0.6u ng=1 m=1 mm_ok=1
XMDOP3 POAVDD pcasc POAVDD POAVDD sg13_hv_pmos w=1.2u l=0.6u ng=1 m=1 mm_ok=1
XMDOP4 POAVDD pcasc POAVDD POAVDD sg13_hv_pmos w=1.2u l=0.6u ng=1 m=1 mm_ok=1
XMDN1 POAVSS nbias POAVSS POAVSS sg13_hv_nmos w=0.6u l=2.4u ng=1 m=1 mm_ok=1
XMDN2 POAVSS nbias POAVSS POAVSS sg13_hv_nmos w=0.6u l=2.4u ng=1 m=1 mm_ok=1
XMDON1 nIOADISABLE IOADISABLE POAVSS POAVSS sg13_hv_nmos w=0.6u l=0.6u ng=1 m=1 mm_ok=1
XMDON2 ntlg IOADISABLE POAVSS POAVSS sg13_hv_nmos w=0.6u l=0.6u ng=1 m=1 mm_ok=1
XMDON3 ndrive IOADISABLE POAVSS POAVSS sg13_hv_nmos w=0.6u l=0.6u ng=1 m=1 mm_ok=1
XMDON4 IOAIREF IOADISABLE POAVSS POAVSS sg13_hv_nmos w=0.6u l=0.6u ng=1 m=1 mm_ok=1
XMDP7 POAVDD pbias POAVDD POAVDD sg13_hv_pmos w=1.2u l=1.2u ng=1 m=1 mm_ok=1
XMDP8 POAVDD pbias POAVDD POAVDD sg13_hv_pmos w=1.2u l=1.2u ng=1 m=1 mm_ok=1
XMDN7 POAVSS nbias POAVSS POAVSS sg13_hv_nmos w=0.6u l=2.4u ng=1 m=1 mm_ok=1
XMDN8 POAVSS nbias POAVSS POAVSS sg13_hv_nmos w=0.6u l=2.4u ng=1 m=1 mm_ok=1
XMDN9 POAVSS POAVSS POAVSS POAVSS sg13_hv_nmos w=1.2u l=0.45u ng=1 m=1 mm_ok=1
XMDN10 POAVSS POAVSS POAVSS POAVSS sg13_hv_nmos w=1.2u l=0.45u ng=1 m=1 mm_ok=1
XMDN11 POAVSS POAVSS POAVSS POAVSS sg13_hv_nmos w=1.2u l=0.45u ng=1 m=1 mm_ok=1
XMDN12 POAVSS POAVSS POAVSS POAVSS sg13_hv_nmos w=1.2u l=0.45u ng=1 m=1 mm_ok=1
XMDN13 POAVSS POAVSS POAVSS POAVSS sg13_hv_nmos w=2.4u l=0.45u ng=1 m=1 mm_ok=1
XMDN14 POAVSS POAVSS POAVSS POAVSS sg13_hv_nmos w=2.4u l=0.45u ng=1 m=1 mm_ok=1
XMDN15 POAVSS POAVSS POAVSS POAVSS sg13_hv_nmos w=2.4u l=0.45u ng=1 m=1 mm_ok=1
XMDN16 POAVSS POAVSS POAVSS POAVSS sg13_hv_nmos w=2.4u l=0.45u ng=1 m=1 mm_ok=1
XMDN17 POAVSS POAVSS POAVSS POAVSS sg13_hv_nmos w=1.2u l=0.45u ng=1 m=1 mm_ok=1
XMDN18 POAVSS POAVSS POAVSS POAVSS sg13_hv_nmos w=1.2u l=0.45u ng=1 m=1 mm_ok=1
XMDN19 POAVSS POAVSS POAVSS POAVSS sg13_hv_nmos w=1.2u l=0.45u ng=1 m=1 mm_ok=1
XMDN20 POAVSS POAVSS POAVSS POAVSS sg13_hv_nmos w=1.2u l=0.45u ng=1 m=1 mm_ok=1
XMDN21 POAVSS IOAIREF POAVSS POAVSS sg13_hv_nmos w=0.6u l=2.4u ng=1 m=1 mm_ok=1
XMDN22 POAVSS IOAIREF POAVSS POAVSS sg13_hv_nmos w=0.6u l=2.4u ng=1 m=1 mm_ok=1
XMDP9 POAVDD pcasc POAVDD POAVDD sg13_hv_pmos w=1u l=10u ng=1 m=1 mm_ok=1
XMDN23 POAVSS ncasc POAVSS POAVSS sg13_hv_nmos w=0.4u l=10u ng=1 m=1 mm_ok=1
XMDP10 POAVDD pcasc POAVDD POAVDD sg13_hv_pmos w=1u l=10u ng=1 m=1 mm_ok=1
XMDN24 POAVSS ncasc POAVSS POAVSS sg13_hv_nmos w=0.4u l=10u ng=1 m=1 mm_ok=1
XMDP11 POAVDD pbias POAVDD POAVDD sg13_hv_pmos w=1.2u l=1.2u ng=1 m=1 mm_ok=1
XMDP12 POAVDD pbias POAVDD POAVDD sg13_hv_pmos w=1.2u l=1.2u ng=1 m=1 mm_ok=1
XMDP13 POAVDD pcasc POAVDD POAVDD sg13_hv_pmos w=1.2u l=0.6u ng=1 m=1 mm_ok=1
XMDP14 POAVDD pcasc POAVDD POAVDD sg13_hv_pmos w=1.2u l=0.6u ng=1 m=1 mm_ok=1
XMDN25 POAVSS POAVSS POAVSS POAVSS sg13_hv_nmos w=0.6u l=2.4u ng=1 m=1 mm_ok=1
XMDN26 POAVSS POAVSS POAVSS POAVSS sg13_hv_nmos w=0.6u l=2.4u ng=1 m=1 mm_ok=1
XMDN27 POAVSS ncasc POAVSS POAVSS sg13_hv_nmos w=0.6u l=0.6u ng=1 m=1 mm_ok=1
XMDN28 POAVSS ncasc POAVSS POAVSS sg13_hv_nmos w=0.6u l=0.6u ng=1 m=1 mm_ok=1
XMDP15 POAVDD POAVDD POAVDD POAVDD sg13_hv_pmos w=2.4u l=0.4u ng=1 m=8 mm_ok=1
XMDN29 POAVSS POAVSS POAVSS POAVSS sg13_hv_nmos w=1.2u l=0.6u ng=1 m=8 mm_ok=1
XMDP16 POAVDD POAVDD POAVDD POAVDD sg13_hv_pmos w=2.4u l=0.4u ng=1 m=2 mm_ok=1
XMDN30 POAVSS POAVSS POAVSS POAVSS sg13_hv_nmos w=1.2u l=0.6u ng=1 m=2 mm_ok=1
XMDP17 POAVDD POAVDD POAVDD POAVDD sg13_hv_pmos w=2.4u l=0.4u ng=1 m=8 mm_ok=1
XMDN31 POAVSS POAVSS POAVSS POAVSS sg13_hv_nmos w=1.2u l=0.6u ng=1 m=8 mm_ok=1
XMDOP5 nIOADISABLE IOADISABLE POAVDD POAVDD sg13_hv_pmos w=1.2u l=0.6u ng=1 m=1 mm_ok=1
XMDOP6 ptlg nIOADISABLE POAVDD POAVDD sg13_hv_pmos w=1.2u l=0.6u ng=1 m=1 mm_ok=1
XMDOP7 pdrive nIOADISABLE POAVDD POAVDD sg13_hv_pmos w=1.2u l=0.6u ng=1 m=1 mm_ok=1
XMDOP8 pcasc nIOADISABLE POAVDD POAVDD sg13_hv_pmos w=1.2u l=0.6u ng=1 m=1 mm_ok=1
.ends


* expanding   symbol:  ptat_curr_gen.sym # of pins=6
** sym_path: xschem/ptat_curr_gen.sym
** sch_path: xschem/ptat_curr_gen.sch
.subckt ptat_curr_gen PCSVDD CSOUT1 CSOUT2 CSOUT3 CSSTARTUP PCSVSS
*.iopin PCSVDD
*.iopin PCSVSS
*.opin CSOUT1
*.opin CSOUT2
*.opin CSOUT3
*.opin CSSTARTUP
XM1 net2 net2 PCSVSS PCSVSS sg13_hv_nmos w=2u l=2u ng=1 m=1 mm_ok=1
XM2 net1 net2 res_tap PCSVSS sg13_hv_nmos w=10u l=2u ng=1 m=1 mm_ok=1
XM3 net2 net1 PCSVDD PCSVDD sg13_hv_pmos w=0.4u l=1u ng=1 m=1 mm_ok=1
XM4 net1 net1 PCSVDD PCSVDD sg13_hv_pmos w=0.4u l=1u ng=1 m=1 mm_ok=1
XR1 res_tap PCSVSS PCSVSS rhigh w=0.5e-6 l=30e-6 m=1 b=21 mm_ok=1
XM5 CSOUT3 net1 PCSVDD PCSVDD sg13_hv_pmos w=0.4u l=1u ng=1 m=1 mm_ok=1
XM6 CSOUT2 net1 PCSVDD PCSVDD sg13_hv_pmos w=0.4u l=1u ng=1 m=1 mm_ok=1
XM7 CSOUT1 net1 PCSVDD PCSVDD sg13_hv_pmos w=0.4u l=1u ng=1 m=1 mm_ok=1
XMS1 CSSTARTUP net1 PCSVDD PCSVDD sg13_hv_pmos w=0.4u l=1u ng=1 m=1 mm_ok=1
XMS3 PCSVSS CSSTARTUP net1 PCSVDD sg13_hv_pmos w=0.4u l=1u ng=1 m=1 mm_ok=1
XMS53 CSSTARTUP PCSVDD net3 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS54 net3 PCSVDD net4 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS55 net4 PCSVDD net5 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS56 net5 PCSVDD net6 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS57 net6 PCSVDD net19 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS58 net19 PCSVDD net7 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS59 net7 PCSVDD net8 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS60 net8 PCSVDD net9 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS61 net9 PCSVDD net10 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS62 net10 PCSVDD net20 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS63 net20 PCSVDD net11 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS64 net11 PCSVDD net12 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS65 net12 PCSVDD net13 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS66 net13 PCSVDD net14 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS67 net14 PCSVDD net21 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS68 net21 PCSVDD net15 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS69 net15 PCSVDD net16 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS70 net16 PCSVDD net17 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS71 net17 PCSVDD net18 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS72 net18 PCSVDD net41 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS73 net41 PCSVDD net22 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS74 net22 PCSVDD net23 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS75 net23 PCSVDD net24 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS76 net24 PCSVDD net25 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS77 net25 PCSVDD net38 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS78 net38 PCSVDD net26 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS79 net26 PCSVDD net27 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS80 net27 PCSVDD net28 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS81 net28 PCSVDD net29 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS82 net29 PCSVDD net39 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS83 net39 PCSVDD net30 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS84 net30 PCSVDD net31 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS85 net31 PCSVDD net32 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS86 net32 PCSVDD net33 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS87 net33 PCSVDD net40 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS88 net40 PCSVDD net34 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS89 net34 PCSVDD net35 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS90 net35 PCSVDD net36 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS91 net36 PCSVDD net37 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS92 net37 PCSVDD net50 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS93 net50 PCSVDD net42 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS94 net42 PCSVDD net43 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS95 net43 PCSVDD net44 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS96 net44 PCSVDD net45 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS97 net45 PCSVDD net51 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS98 net51 PCSVDD net46 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS99 net46 PCSVDD net47 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS100 net47 PCSVDD net48 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS101 net48 PCSVDD net49 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS102 net49 PCSVDD net349 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS2 net199 PCSVDD net52 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS4 net52 PCSVDD net53 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS5 net53 PCSVDD net54 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS6 net54 PCSVDD net55 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS7 net55 PCSVDD net68 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS8 net68 PCSVDD net56 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS9 net56 PCSVDD net57 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS10 net57 PCSVDD net58 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS11 net58 PCSVDD net59 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS12 net59 PCSVDD net69 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS13 net69 PCSVDD net60 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS14 net60 PCSVDD net61 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS15 net61 PCSVDD net62 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS16 net62 PCSVDD net63 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS17 net63 PCSVDD net70 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS18 net70 PCSVDD net64 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS19 net64 PCSVDD net65 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS20 net65 PCSVDD net66 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS21 net66 PCSVDD net67 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS22 net67 PCSVDD net90 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS23 net90 PCSVDD net71 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS24 net71 PCSVDD net72 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS25 net72 PCSVDD net73 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS26 net73 PCSVDD net74 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS27 net74 PCSVDD net87 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS28 net87 PCSVDD net75 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS29 net75 PCSVDD net76 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS30 net76 PCSVDD net77 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS31 net77 PCSVDD net78 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS32 net78 PCSVDD net88 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS33 net88 PCSVDD net79 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS34 net79 PCSVDD net80 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS35 net80 PCSVDD net81 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS36 net81 PCSVDD net82 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS37 net82 PCSVDD net89 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS38 net89 PCSVDD net83 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS39 net83 PCSVDD net84 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS40 net84 PCSVDD net85 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS41 net85 PCSVDD net86 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS42 net86 PCSVDD net99 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS43 net99 PCSVDD net91 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS44 net91 PCSVDD net92 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS45 net92 PCSVDD net93 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS46 net93 PCSVDD net94 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS47 net94 PCSVDD net100 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS48 net100 PCSVDD net95 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS49 net95 PCSVDD net96 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS50 net96 PCSVDD net97 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS51 net97 PCSVDD net98 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS52 net98 PCSVDD net350 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS103 net200 PCSVDD net101 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS104 net101 PCSVDD net102 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS105 net102 PCSVDD net103 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS106 net103 PCSVDD net104 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS107 net104 PCSVDD net117 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS108 net117 PCSVDD net105 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS109 net105 PCSVDD net106 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS110 net106 PCSVDD net107 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS111 net107 PCSVDD net108 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS112 net108 PCSVDD net118 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS113 net118 PCSVDD net109 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS114 net109 PCSVDD net110 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS115 net110 PCSVDD net111 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS116 net111 PCSVDD net112 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS117 net112 PCSVDD net119 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS118 net119 PCSVDD net113 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS119 net113 PCSVDD net114 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS120 net114 PCSVDD net115 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS121 net115 PCSVDD net116 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS122 net116 PCSVDD net139 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS123 net139 PCSVDD net120 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS124 net120 PCSVDD net121 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS125 net121 PCSVDD net122 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS126 net122 PCSVDD net123 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS127 net123 PCSVDD net136 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS128 net136 PCSVDD net124 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS129 net124 PCSVDD net125 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS130 net125 PCSVDD net126 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS131 net126 PCSVDD net127 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS132 net127 PCSVDD net137 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS133 net137 PCSVDD net128 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS134 net128 PCSVDD net129 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS135 net129 PCSVDD net130 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS136 net130 PCSVDD net131 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS137 net131 PCSVDD net138 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS138 net138 PCSVDD net132 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS139 net132 PCSVDD net133 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS140 net133 PCSVDD net134 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS141 net134 PCSVDD net135 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS142 net135 PCSVDD net148 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS143 net148 PCSVDD net140 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS144 net140 PCSVDD net141 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS145 net141 PCSVDD net142 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS146 net142 PCSVDD net143 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS147 net143 PCSVDD net149 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS148 net149 PCSVDD net144 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS149 net144 PCSVDD net145 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS150 net145 PCSVDD net146 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS151 net146 PCSVDD net147 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS152 net147 PCSVDD net400 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS153 net201 PCSVDD net150 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS154 net150 PCSVDD net151 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS155 net151 PCSVDD net152 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS156 net152 PCSVDD net153 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS157 net153 PCSVDD net166 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS158 net166 PCSVDD net154 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS159 net154 PCSVDD net155 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS160 net155 PCSVDD net156 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS161 net156 PCSVDD net157 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS162 net157 PCSVDD net167 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS163 net167 PCSVDD net158 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS164 net158 PCSVDD net159 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS165 net159 PCSVDD net160 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS166 net160 PCSVDD net161 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS167 net161 PCSVDD net168 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS168 net168 PCSVDD net162 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS169 net162 PCSVDD net163 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS170 net163 PCSVDD net164 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS171 net164 PCSVDD net165 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS172 net165 PCSVDD net188 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS173 net188 PCSVDD net169 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS174 net169 PCSVDD net170 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS175 net170 PCSVDD net171 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS176 net171 PCSVDD net172 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS177 net172 PCSVDD net185 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS178 net185 PCSVDD net173 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS179 net173 PCSVDD net174 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS180 net174 PCSVDD net175 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS181 net175 PCSVDD net176 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS182 net176 PCSVDD net186 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS183 net186 PCSVDD net177 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS184 net177 PCSVDD net178 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS185 net178 PCSVDD net179 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS186 net179 PCSVDD net180 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS187 net180 PCSVDD net187 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS188 net187 PCSVDD net181 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS189 net181 PCSVDD net182 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS190 net182 PCSVDD net183 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS191 net183 PCSVDD net184 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS192 net184 PCSVDD net197 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS193 net197 PCSVDD net189 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS194 net189 PCSVDD net190 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS195 net190 PCSVDD net191 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS196 net191 PCSVDD net192 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS197 net192 PCSVDD net198 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS198 net198 PCSVDD net193 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS199 net193 PCSVDD net194 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS200 net194 PCSVDD net195 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS201 net195 PCSVDD net196 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS202 net196 PCSVDD net401 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS203 net401 PCSVDD net202 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS204 net202 PCSVDD net203 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS205 net203 PCSVDD net204 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS206 net204 PCSVDD net205 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS207 net205 PCSVDD net218 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS208 net218 PCSVDD net206 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS209 net206 PCSVDD net207 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS210 net207 PCSVDD net208 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS211 net208 PCSVDD net209 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS212 net209 PCSVDD net219 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS213 net219 PCSVDD net210 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS214 net210 PCSVDD net211 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS215 net211 PCSVDD net212 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS216 net212 PCSVDD net213 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS217 net213 PCSVDD net220 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS218 net220 PCSVDD net214 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS219 net214 PCSVDD net215 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS220 net215 PCSVDD net216 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS221 net216 PCSVDD net217 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS222 net217 PCSVDD net240 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS223 net240 PCSVDD net221 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS224 net221 PCSVDD net222 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS225 net222 PCSVDD net223 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS226 net223 PCSVDD net224 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS227 net224 PCSVDD net237 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS228 net237 PCSVDD net225 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS229 net225 PCSVDD net226 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS230 net226 PCSVDD net227 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS231 net227 PCSVDD net228 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS232 net228 PCSVDD net238 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS233 net238 PCSVDD net229 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS234 net229 PCSVDD net230 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS235 net230 PCSVDD net231 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS236 net231 PCSVDD net232 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS237 net232 PCSVDD net239 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS238 net239 PCSVDD net233 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS239 net233 PCSVDD net234 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS240 net234 PCSVDD net235 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS241 net235 PCSVDD net236 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS242 net236 PCSVDD net249 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS243 net249 PCSVDD net241 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS244 net241 PCSVDD net242 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS245 net242 PCSVDD net243 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS246 net243 PCSVDD net244 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS247 net244 PCSVDD net250 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS248 net250 PCSVDD net245 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS249 net245 PCSVDD net246 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS250 net246 PCSVDD net247 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS251 net247 PCSVDD net248 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS252 net248 PCSVDD net440 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS253 net349 PCSVDD net251 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS254 net251 PCSVDD net252 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS255 net252 PCSVDD net253 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS256 net253 PCSVDD net254 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS257 net254 PCSVDD net267 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS258 net267 PCSVDD net255 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS259 net255 PCSVDD net256 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS260 net256 PCSVDD net257 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS261 net257 PCSVDD net258 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS262 net258 PCSVDD net268 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS263 net268 PCSVDD net259 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS264 net259 PCSVDD net260 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS265 net260 PCSVDD net261 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS266 net261 PCSVDD net262 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS267 net262 PCSVDD net269 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS268 net269 PCSVDD net263 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS269 net263 PCSVDD net264 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS270 net264 PCSVDD net265 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS271 net265 PCSVDD net266 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS272 net266 PCSVDD net289 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS273 net289 PCSVDD net270 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS274 net270 PCSVDD net271 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS275 net271 PCSVDD net272 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS276 net272 PCSVDD net273 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS277 net273 PCSVDD net286 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS278 net286 PCSVDD net274 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS279 net274 PCSVDD net275 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS280 net275 PCSVDD net276 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS281 net276 PCSVDD net277 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS282 net277 PCSVDD net287 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS283 net287 PCSVDD net278 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS284 net278 PCSVDD net279 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS285 net279 PCSVDD net280 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS286 net280 PCSVDD net281 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS287 net281 PCSVDD net288 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS288 net288 PCSVDD net282 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS289 net282 PCSVDD net283 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS290 net283 PCSVDD net284 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS291 net284 PCSVDD net285 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS292 net285 PCSVDD net298 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS293 net298 PCSVDD net290 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS294 net290 PCSVDD net291 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS295 net291 PCSVDD net292 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS296 net292 PCSVDD net293 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS297 net293 PCSVDD net299 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS298 net299 PCSVDD net294 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS299 net294 PCSVDD net295 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS300 net295 PCSVDD net296 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS301 net296 PCSVDD net297 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS302 net297 PCSVDD net410 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS303 net350 PCSVDD net300 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS304 net300 PCSVDD net301 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS305 net301 PCSVDD net302 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS306 net302 PCSVDD net303 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS307 net303 PCSVDD net316 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS308 net316 PCSVDD net304 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS309 net304 PCSVDD net305 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS310 net305 PCSVDD net306 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS311 net306 PCSVDD net307 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS312 net307 PCSVDD net317 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS313 net317 PCSVDD net308 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS314 net308 PCSVDD net309 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS315 net309 PCSVDD net310 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS316 net310 PCSVDD net311 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS317 net311 PCSVDD net318 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS318 net318 PCSVDD net312 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS319 net312 PCSVDD net313 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS320 net313 PCSVDD net314 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS321 net314 PCSVDD net315 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS322 net315 PCSVDD net338 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS323 net338 PCSVDD net319 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS324 net319 PCSVDD net320 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS325 net320 PCSVDD net321 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS326 net321 PCSVDD net322 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS327 net322 PCSVDD net335 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS328 net335 PCSVDD net323 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS329 net323 PCSVDD net324 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS330 net324 PCSVDD net325 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS331 net325 PCSVDD net326 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS332 net326 PCSVDD net336 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS333 net336 PCSVDD net327 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS334 net327 PCSVDD net328 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS335 net328 PCSVDD net329 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS336 net329 PCSVDD net330 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS337 net330 PCSVDD net337 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS338 net337 PCSVDD net331 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS339 net331 PCSVDD net332 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS340 net332 PCSVDD net333 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS341 net333 PCSVDD net334 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS342 net334 PCSVDD net347 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS343 net347 PCSVDD net339 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS344 net339 PCSVDD net340 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS345 net340 PCSVDD net341 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS346 net341 PCSVDD net342 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS347 net342 PCSVDD net348 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS348 net348 PCSVDD net343 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS349 net343 PCSVDD net344 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS350 net344 PCSVDD net345 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS351 net345 PCSVDD net346 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS352 net346 PCSVDD net420 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS353 net400 PCSVDD net351 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS354 net351 PCSVDD net352 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS355 net352 PCSVDD net353 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS356 net353 PCSVDD net354 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS357 net354 PCSVDD net367 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS358 net367 PCSVDD net355 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS359 net355 PCSVDD net356 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS360 net356 PCSVDD net357 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS361 net357 PCSVDD net358 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS362 net358 PCSVDD net368 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS363 net368 PCSVDD net359 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS364 net359 PCSVDD net360 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS365 net360 PCSVDD net361 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS366 net361 PCSVDD net362 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS367 net362 PCSVDD net369 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS368 net369 PCSVDD net363 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS369 net363 PCSVDD net364 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS370 net364 PCSVDD net365 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS371 net365 PCSVDD net366 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS372 net366 PCSVDD net389 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS373 net389 PCSVDD net370 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS374 net370 PCSVDD net371 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS375 net371 PCSVDD net372 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS376 net372 PCSVDD net373 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS377 net373 PCSVDD net386 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS378 net386 PCSVDD net374 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS379 net374 PCSVDD net375 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS380 net375 PCSVDD net376 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS381 net376 PCSVDD net377 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS382 net377 PCSVDD net387 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS383 net387 PCSVDD net378 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS384 net378 PCSVDD net379 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS385 net379 PCSVDD net380 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS386 net380 PCSVDD net381 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS387 net381 PCSVDD net388 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS388 net388 PCSVDD net382 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS389 net382 PCSVDD net383 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS390 net383 PCSVDD net384 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS391 net384 PCSVDD net385 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS392 net385 PCSVDD net398 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS393 net398 PCSVDD net390 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS394 net390 PCSVDD net391 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS395 net391 PCSVDD net392 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS396 net392 PCSVDD net393 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS397 net393 PCSVDD net399 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS398 net399 PCSVDD net394 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS399 net394 PCSVDD net395 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS400 net395 PCSVDD net396 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS401 net396 PCSVDD net397 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS402 net397 PCSVDD net430 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS403 net410 PCSVDD net402 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS404 net402 PCSVDD net403 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS405 net403 PCSVDD net404 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS406 net404 PCSVDD net405 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS407 net405 PCSVDD net411 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS408 net411 PCSVDD net406 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS409 net406 PCSVDD net407 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS410 net407 PCSVDD net408 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS411 net408 PCSVDD net409 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS412 net409 PCSVDD net450 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS413 net420 PCSVDD net412 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS414 net412 PCSVDD net413 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS415 net413 PCSVDD net414 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS416 net414 PCSVDD net415 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS417 net415 PCSVDD net421 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS418 net421 PCSVDD net416 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS419 net416 PCSVDD net417 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS420 net417 PCSVDD net418 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS421 net418 PCSVDD net419 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS422 net419 PCSVDD net460 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS423 net430 PCSVDD net422 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS424 net422 PCSVDD net423 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS425 net423 PCSVDD net424 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS426 net424 PCSVDD net425 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS427 net425 PCSVDD net431 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS428 net431 PCSVDD net426 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS429 net426 PCSVDD net427 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS430 net427 PCSVDD net428 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS431 net428 PCSVDD net429 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS432 net429 PCSVDD net470 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS433 net440 PCSVDD net432 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS434 net432 PCSVDD net433 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS435 net433 PCSVDD net434 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS436 net434 PCSVDD net435 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS437 net435 PCSVDD net441 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS438 net441 PCSVDD net436 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS439 net436 PCSVDD net437 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS440 net437 PCSVDD net438 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS441 net438 PCSVDD net439 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS442 net439 PCSVDD net480 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS443 net450 PCSVDD net442 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS444 net442 PCSVDD net443 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS445 net443 PCSVDD net444 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS446 net444 PCSVDD net445 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS447 net445 PCSVDD net451 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS448 net451 PCSVDD net446 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS449 net446 PCSVDD net447 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS450 net447 PCSVDD net448 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS451 net448 PCSVDD net449 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS452 net449 PCSVDD net199 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS453 net460 PCSVDD net452 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS454 net452 PCSVDD net453 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS455 net453 PCSVDD net454 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS456 net454 PCSVDD net455 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS457 net455 PCSVDD net461 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS458 net461 PCSVDD net456 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS459 net456 PCSVDD net457 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS460 net457 PCSVDD net458 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS461 net458 PCSVDD net459 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS462 net459 PCSVDD net200 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS463 net470 PCSVDD net462 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS464 net462 PCSVDD net463 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS465 net463 PCSVDD net464 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS466 net464 PCSVDD net465 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS467 net465 PCSVDD net471 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS468 net471 PCSVDD net466 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS469 net466 PCSVDD net467 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS470 net467 PCSVDD net468 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS471 net468 PCSVDD net469 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS472 net469 PCSVDD net201 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS473 net480 PCSVDD net472 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS474 net472 PCSVDD net473 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS475 net473 PCSVDD net474 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS476 net474 PCSVDD net475 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS477 net475 PCSVDD net481 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS478 net481 PCSVDD net476 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS479 net476 PCSVDD net477 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS480 net477 PCSVDD net478 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS481 net478 PCSVDD net479 PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMS482 net479 PCSVDD PCSVSS PCSVSS sg13_hv_nmos w=0.3u l=10u ng=1 m=1 mm_ok=1
XMD1 PCSVSS PCSVSS PCSVSS PCSVSS sg13_hv_nmos w=10u l=2u ng=1 m=1 mm_ok=1
XMD2 PCSVSS PCSVSS PCSVSS PCSVSS sg13_hv_nmos w=10u l=2u ng=1 m=1 mm_ok=1
XMD3 PCSVSS PCSVSS PCSVSS PCSVSS sg13_hv_nmos w=5u l=2u ng=1 m=1 mm_ok=1
XMD4 PCSVSS PCSVSS PCSVSS PCSVSS sg13_hv_nmos w=5u l=2u ng=1 m=1 mm_ok=1
XMD5 PCSVSS PCSVSS PCSVSS PCSVSS sg13_hv_nmos w=5u l=2u ng=1 m=1 mm_ok=1
XMD6 PCSVSS PCSVSS PCSVSS PCSVSS sg13_hv_nmos w=5u l=2u ng=1 m=1 mm_ok=1
XMD7 PCSVSS PCSVSS PCSVSS PCSVSS sg13_hv_nmos w=5u l=2u ng=1 m=1 mm_ok=1
XMD8 PCSVSS PCSVSS PCSVSS PCSVSS sg13_hv_nmos w=5u l=2u ng=1 m=1 mm_ok=1
XMD9 PCSVSS PCSVSS PCSVSS PCSVSS sg13_hv_nmos w=2u l=2u ng=1 m=1 mm_ok=1
XMD10 PCSVSS PCSVSS PCSVSS PCSVSS sg13_hv_nmos w=2u l=2u ng=1 m=1 mm_ok=1
XMD11 PCSVSS PCSVSS PCSVSS PCSVSS sg13_hv_nmos w=1u l=2u ng=1 m=1 mm_ok=1
XMD12 PCSVSS PCSVSS PCSVSS PCSVSS sg13_hv_nmos w=1u l=2u ng=1 m=1 mm_ok=1
XMD13 PCSVSS PCSVSS PCSVSS PCSVSS sg13_hv_nmos w=1u l=2u ng=1 m=1 mm_ok=1
XMD14 PCSVSS PCSVSS PCSVSS PCSVSS sg13_hv_nmos w=1u l=2u ng=1 m=1 mm_ok=1
XMD15 PCSVSS PCSVSS PCSVSS PCSVSS sg13_hv_nmos w=1u l=2u ng=1 m=1 mm_ok=1
XMD16 PCSVSS PCSVSS PCSVSS PCSVSS sg13_hv_nmos w=1u l=2u ng=1 m=1 mm_ok=1
XMD17 PCSVDD PCSVDD PCSVDD PCSVDD sg13_hv_pmos w=0.4u l=1u ng=1 m=1 mm_ok=1
XMD24 PCSVDD PCSVDD PCSVDD PCSVDD sg13_hv_pmos w=0.4u l=1u ng=1 m=1 mm_ok=1
XMD31 PCSVDD PCSVDD PCSVDD PCSVDD sg13_hv_pmos w=0.4u l=1u ng=1 m=1 mm_ok=1
XMD18 PCSVDD PCSVDD PCSVDD PCSVDD sg13_hv_pmos w=0.4u l=1u ng=1 m=1 mm_ok=1
XMD19 PCSVDD PCSVDD PCSVDD PCSVDD sg13_hv_pmos w=0.4u l=1u ng=1 m=1 mm_ok=1
XMD20 PCSVDD PCSVDD PCSVDD PCSVDD sg13_hv_pmos w=0.4u l=1u ng=1 m=1 mm_ok=1
XMD21 PCSVDD PCSVDD PCSVDD PCSVDD sg13_hv_pmos w=0.4u l=1u ng=1 m=1 mm_ok=1
XMD22 PCSVDD PCSVDD PCSVDD PCSVDD sg13_hv_pmos w=0.4u l=1u ng=1 m=1 mm_ok=1
XMD23 PCSVDD PCSVDD PCSVDD PCSVDD sg13_hv_pmos w=0.4u l=1u ng=1 m=1 mm_ok=1
XMD25 PCSVDD PCSVDD PCSVDD PCSVDD sg13_hv_pmos w=0.4u l=1u ng=1 m=1 mm_ok=1
XMD26 PCSVDD PCSVDD PCSVDD PCSVDD sg13_hv_pmos w=0.4u l=1u ng=1 m=1 mm_ok=1
XMD27 PCSVDD PCSVDD PCSVDD PCSVDD sg13_hv_pmos w=0.4u l=1u ng=1 m=1 mm_ok=1
XMD28 PCSVDD PCSVDD PCSVDD PCSVDD sg13_hv_pmos w=0.4u l=1u ng=1 m=1 mm_ok=1
XMD29 PCSVDD PCSVDD PCSVDD PCSVDD sg13_hv_pmos w=0.4u l=1u ng=1 m=1 mm_ok=1
XMD30 PCSVDD PCSVDD PCSVDD PCSVDD sg13_hv_pmos w=0.4u l=1u ng=1 m=1 mm_ok=1
XMD32 PCSVDD PCSVDD PCSVDD PCSVDD sg13_hv_pmos w=0.4u l=1u ng=1 m=1 mm_ok=1
XMD33 PCSVDD PCSVDD PCSVDD PCSVDD sg13_hv_pmos w=0.4u l=1u ng=1 m=1 mm_ok=1
XMD34 PCSVDD PCSVDD PCSVDD PCSVDD sg13_hv_pmos w=0.4u l=1u ng=1 m=1 mm_ok=1
XMD35 PCSVDD PCSVDD PCSVDD PCSVDD sg13_hv_pmos w=0.4u l=1u ng=1 m=1 mm_ok=1
XMD36 PCSVDD PCSVDD PCSVDD PCSVDD sg13_hv_pmos w=0.4u l=1u ng=1 m=1 mm_ok=1
.ends


* expanding   symbol:  r2r_dac.sym # of pins=14
** sym_path: xschem/r2r_dac.sym
** sch_path: xschem/r2r_dac.sch
.subckt r2r_dac PDACVDD ODACOUT IDACVTAP IDACIREF nD7 nD0 nD2 nD4 nD5 nD6 nD3 nD1 PDACVSS
+ IDACDISABLE
*.iopin PDACVDD
*.iopin PDACVSS
*.ipin nD0
*.ipin nD1
*.ipin nD2
*.ipin IDACIREF
*.opin ODACOUT
*.ipin nD3
*.ipin nD4
*.ipin nD5
*.ipin nD6
*.ipin nD7
*.ipin IDACVTAP
*.ipin IDACDISABLE
XR1 net1 PDACVSS PDACVSS rhigh w=0.5e-6 l=15e-6 m=1 b=0 mm_ok=1
XR2 net8 net1 PDACVSS rhigh w=0.5e-6 l=15e-6 m=1 b=0 mm_ok=1
XR4 net2 nD0 PDACVSS rhigh w=0.5e-6 l=15e-6 m=1 b=0 mm_ok=1
XR5 net7 net2 PDACVSS rhigh w=0.5e-6 l=15e-6 m=1 b=0 mm_ok=1
XR6 net3 nD1 PDACVSS rhigh w=0.5e-6 l=15e-6 m=1 b=0 mm_ok=1
XR7 net6 net3 PDACVSS rhigh w=0.5e-6 l=15e-6 m=1 b=0 mm_ok=1
XR8 net4 nD2 PDACVSS rhigh w=0.5e-6 l=15e-6 m=1 b=0 mm_ok=1
XR9 net5 net4 PDACVSS rhigh w=0.5e-6 l=15e-6 m=1 b=0 mm_ok=1
XR10 net7 net8 PDACVSS rhigh w=0.5e-6 l=15e-6 m=1 b=0 mm_ok=1
XR11 net6 net7 PDACVSS rhigh w=0.5e-6 l=15e-6 m=1 b=0 mm_ok=1
XR12 net5 net6 PDACVSS rhigh w=0.5e-6 l=15e-6 m=1 b=0 mm_ok=1
XR14 UNBUF_DAC net9 PDACVSS rhigh w=0.5e-6 l=14e-6 m=1 b=0 mm_ok=1
XR3 net10 nD3 PDACVSS rhigh w=0.5e-6 l=15e-6 m=1 b=0 mm_ok=1
XR13 net13 net10 PDACVSS rhigh w=0.5e-6 l=15e-6 m=1 b=0 mm_ok=1
XR15 net11 nD4 PDACVSS rhigh w=0.5e-6 l=15e-6 m=1 b=0 mm_ok=1
XR16 net12 net11 PDACVSS rhigh w=0.5e-6 l=15e-6 m=1 b=0 mm_ok=1
XR17 net13 net5 PDACVSS rhigh w=0.5e-6 l=15e-6 m=1 b=0 mm_ok=1
XR18 net12 net13 PDACVSS rhigh w=0.5e-6 l=15e-6 m=1 b=0 mm_ok=1
XR19 net14 nD5 PDACVSS rhigh w=0.5e-6 l=15e-6 m=1 b=0 mm_ok=1
XR20 net17 net14 PDACVSS rhigh w=0.5e-6 l=15e-6 m=1 b=0 mm_ok=1
XR21 net15 nD6 PDACVSS rhigh w=0.5e-6 l=15e-6 m=1 b=0 mm_ok=1
XR22 net16 net15 PDACVSS rhigh w=0.5e-6 l=15e-6 m=1 b=0 mm_ok=1
XR23 net17 net12 PDACVSS rhigh w=0.5e-6 l=15e-6 m=1 b=0 mm_ok=1
XR24 net16 net17 PDACVSS rhigh w=0.5e-6 l=15e-6 m=1 b=0 mm_ok=1
XR25 net18 nD7 PDACVSS rhigh w=0.5e-6 l=15e-6 m=1 b=0 mm_ok=1
XR26 UNBUF_DAC net18 PDACVSS rhigh w=0.5e-6 l=15e-6 m=1 b=0 mm_ok=1
XR27 UNBUF_DAC net16 PDACVSS rhigh w=0.5e-6 l=15e-6 m=1 b=0 mm_ok=1
x1 PDACVDD IDACIREF UNBUF_DAC ODACOUT IDACVTAP PDACVSS IDACDISABLE op_amp_ver_2
XM1 net9 nIDACDISABLE ODACOUT PDACVSS sg13_hv_nmos w=1u l=0.45u ng=1 m=1 mm_ok=1
XM2 ODACOUT IDACDISABLE net9 PDACVDD sg13_hv_pmos w=2u l=0.45u ng=1 m=1 mm_ok=1
XRD2 PDACVSS PDACVSS PDACVSS rhigh w=0.5e-6 l=15e-6 m=1 b=0 mm_ok=1
XRD1 PDACVSS PDACVSS PDACVSS rhigh w=0.5e-6 l=15e-6 m=1 b=0 mm_ok=1
XRD3 PDACVSS PDACVSS PDACVSS rhigh w=0.5e-6 l=14e-6 m=1 b=0 mm_ok=1
XM3 nIDACDISABLE IDACDISABLE PDACVSS PDACVSS sg13_hv_nmos w=0.3u l=0.45u ng=1 m=1 mm_ok=1
XM4 nIDACDISABLE IDACDISABLE PDACVDD PDACVDD sg13_hv_pmos w=0.6u l=0.45u ng=1 m=1 mm_ok=1
.ends


* expanding   symbol:  res_divider.sym # of pins=3
** sym_path: xschem/res_divider.sym
** sch_path: xschem/res_divider.sch
.subckt res_divider PRVDD ORTAP PRVSS
*.iopin PRVDD
*.iopin PRVSS
*.opin ORTAP
XR1 PRVSS ORTAP PRVSS rhigh w=0.5e-6 l=298e-6 m=1 b=2 mm_ok=1
XR2 ORTAP PRVDD PRVSS rhigh w=0.5e-6 l=298e-6 m=1 b=2 mm_ok=1
.ends


* expanding   symbol:  digital_decoder.sym # of pins=8
** sym_path: xschem/digital_decoder.sym
** sch_path: xschem/digital_decoder.sch
.subckt digital_decoder PDDVDD DDIN1 DDO_SEL0 DDIN0 DDO_SEL1 DDO_SEL2 DDO_SEL3 PDDVSS
*.ipin DDIN1
*.ipin DDIN0
*.opin DDO_SEL0
*.iopin PDDVDD
*.iopin PDDVSS
*.opin DDO_SEL1
*.opin DDO_SEL2
*.opin DDO_SEL3
XM1 inv_d1 DDIN1 PDDVDD PDDVDD sg13_lv_pmos w=0.3u l=0.13u ng=1 m=1 mm_ok=1
XM2 inv_d1 DDIN1 PDDVSS PDDVSS sg13_lv_nmos w=0.15u l=0.13u ng=1 m=1 mm_ok=1
XM3 d1 inv_d1 PDDVDD PDDVDD sg13_lv_pmos w=0.3u l=0.13u ng=1 m=1 mm_ok=1
XM4 d1 inv_d1 PDDVSS PDDVSS sg13_lv_nmos w=0.15u l=0.13u ng=1 m=1 mm_ok=1
XM5 inv_d0 DDIN0 PDDVDD PDDVDD sg13_lv_pmos w=0.3u l=0.13u ng=1 m=1 mm_ok=1
XM6 inv_d0 DDIN0 PDDVSS PDDVSS sg13_lv_nmos w=0.15u l=0.13u ng=1 m=1 mm_ok=1
XM7 d0 inv_d0 PDDVDD PDDVDD sg13_lv_pmos w=0.3u l=0.13u ng=1 m=1 mm_ok=1
XM8 d0 inv_d0 PDDVSS PDDVSS sg13_lv_nmos w=0.15u l=0.13u ng=1 m=1 mm_ok=1
XM9 DDO_SEL0 inv_d1 PDDVDD PDDVDD sg13_lv_pmos w=0.3u l=0.13u ng=1 m=1 mm_ok=1
XM10 DDO_SEL0 inv_d1 net2 PDDVSS sg13_lv_nmos w=0.15u l=0.13u ng=1 m=1 mm_ok=1
XM11 DDO_SEL1 inv_d1 PDDVDD PDDVDD sg13_lv_pmos w=0.3u l=0.13u ng=1 m=1 mm_ok=1
XM12 DDO_SEL1 inv_d1 net3 PDDVSS sg13_lv_nmos w=0.15u l=0.13u ng=1 m=1 mm_ok=1
XM13 DDO_SEL2 inv_d0 PDDVDD PDDVDD sg13_lv_pmos w=0.3u l=0.13u ng=1 m=1 mm_ok=1
XM14 DDO_SEL2 inv_d0 net4 PDDVSS sg13_lv_nmos w=0.15u l=0.13u ng=1 m=1 mm_ok=1
XM15 DDO_SEL3 d1 PDDVDD PDDVDD sg13_lv_pmos w=0.3u l=0.13u ng=1 m=1 mm_ok=1
XM16 DDO_SEL3 d1 net1 PDDVSS sg13_lv_nmos w=0.15u l=0.13u ng=1 m=1 mm_ok=1
XM19 DDO_SEL0 inv_d0 PDDVDD PDDVDD sg13_lv_pmos w=0.3u l=0.13u ng=1 m=1 mm_ok=1
XM20 DDO_SEL1 d0 PDDVDD PDDVDD sg13_lv_pmos w=0.3u l=0.13u ng=1 m=1 mm_ok=1
XM21 DDO_SEL2 d1 PDDVDD PDDVDD sg13_lv_pmos w=0.3u l=0.13u ng=1 m=1 mm_ok=1
XM22 DDO_SEL3 d0 PDDVDD PDDVDD sg13_lv_pmos w=0.3u l=0.13u ng=1 m=1 mm_ok=1
XM23 net2 inv_d0 PDDVSS PDDVSS sg13_lv_nmos w=0.15u l=0.13u ng=1 m=1 mm_ok=1
XM24 net3 d0 PDDVSS PDDVSS sg13_lv_nmos w=0.15u l=0.13u ng=1 m=1 mm_ok=1
XM25 net4 d1 PDDVSS PDDVSS sg13_lv_nmos w=0.15u l=0.13u ng=1 m=1 mm_ok=1
XM26 net1 d0 PDDVSS PDDVSS sg13_lv_nmos w=0.15u l=0.13u ng=1 m=1 mm_ok=1
.ends


* expanding   symbol:  8x_inverting_digital_level_translator.sym # of pins=19
** sym_path: xschem/8x_inverting_digital_level_translator.sym
** sch_path: xschem/8x_inverting_digital_level_translator.sch
.subckt 8x_inverting_digital_level_translator PLDVDD PLAVDD nLOUT7 LIN7 nLOUT6 LIN6 nLOUT5 LIN5
+ nLOUT4 LIN4 LIN3 nLOUT3 LIN2 nLOUT2 nLOUT1 LIN1 LIN0 nLOUT0 PLVSS
*.ipin LIN7
*.opin nLOUT7
*.iopin PLDVDD
*.iopin PLAVDD
*.iopin PLVSS
*.ipin LIN6
*.ipin LIN5
*.ipin LIN4
*.ipin LIN3
*.ipin LIN2
*.ipin LIN1
*.ipin LIN0
*.opin nLOUT6
*.opin nLOUT5
*.opin nLOUT4
*.opin nLOUT3
*.opin nLOUT2
*.opin nLOUT1
*.opin nLOUT0
x1 PLAVDD PLDVDD LIN7 nLOUT7 PLVSS inverting_digital_level_translator
x2 PLAVDD PLDVDD LIN6 nLOUT6 PLVSS inverting_digital_level_translator
x3 PLAVDD PLDVDD LIN5 nLOUT5 PLVSS inverting_digital_level_translator
x4 PLAVDD PLDVDD LIN4 nLOUT4 PLVSS inverting_digital_level_translator
x5 PLAVDD PLDVDD LIN2 nLOUT2 PLVSS inverting_digital_level_translator
x6 PLAVDD PLDVDD LIN3 nLOUT3 PLVSS inverting_digital_level_translator
x7 PLAVDD PLDVDD LIN1 nLOUT1 PLVSS inverting_digital_level_translator
x8 PLAVDD PLDVDD LIN0 nLOUT0 PLVSS inverting_digital_level_translator
.ends


* expanding   symbol:  4x_digital_level_translator.sym # of pins=11
** sym_path: xschem/4x_digital_level_translator.sym
** sch_path: xschem/4x_digital_level_translator.sch
.subckt 4x_digital_level_translator PLDVDD PLAVDD LIN3 LOUT3 LIN2 LOUT2 LIN1 LOUT1 LIN0 LOUT0 PLVSS
*.iopin PLDVDD
*.iopin PLAVDD
*.iopin PLVSS
*.ipin LIN3
*.ipin LIN2
*.ipin LIN1
*.ipin LIN0
*.opin LOUT3
*.opin LOUT2
*.opin LOUT1
*.opin LOUT0
x1 PLAVDD PLDVDD LIN3 LOUT3 PLVSS digital_level_translator
x2 PLAVDD PLDVDD LIN2 LOUT2 PLVSS digital_level_translator
x3 PLAVDD PLDVDD LIN1 LOUT1 PLVSS digital_level_translator
x4 PLAVDD PLDVDD LIN0 LOUT0 PLVSS digital_level_translator
.ends


* expanding   symbol:  5x_down_digital_translator.sym # of pins=12
** sym_path: xschem/5x_down_digital_translator.sym
** sch_path: xschem/5x_down_digital_translator.sch
.subckt 5x_down_digital_translator PDIGVDD DOUT4 DIN4 DIN3 DOUT3 DIN2 DOUT2 DOUT1 DIN1 DIN0 DOUT0
+ PDIGVSS
*.iopin PDIGVDD
*.iopin PDIGVSS
*.ipin DIN3
*.ipin DIN2
*.ipin DIN1
*.ipin DIN0
*.ipin DIN4
*.opin DOUT3
*.opin DOUT2
*.opin DOUT1
*.opin DOUT0
*.opin DOUT4
x1 PDIGVDD DIN4 DOUT4 PDIGVSS down_digital_translator
x2 PDIGVDD DIN3 DOUT3 PDIGVSS down_digital_translator
x3 PDIGVDD DIN2 DOUT2 PDIGVSS down_digital_translator
x4 PDIGVDD DIN1 DOUT1 PDIGVSS down_digital_translator
x5 PDIGVDD DIN0 DOUT0 PDIGVSS down_digital_translator
.ends


* expanding   symbol:  tie_low.sym # of pins=3
** sym_path: xschem/tie_low.sym
** sch_path: xschem/tie_low.sch
.subckt tie_low PTVDD OTL PTVSS
*.iopin PTVDD
*.iopin PTVSS
*.opin OTL
XMN0 net2 net3 PTVSS PTVSS sg13_lv_nmos w=0.38u l=0.13u ng=1 m=1 mm_ok=1
XMP1 net1 net2 PTVDD PTVDD sg13_lv_pmos w=1u l=0.13u ng=1 m=1 mm_ok=1
XMN1 OTL net1 PTVSS PTVSS sg13_lv_nmos w=0.8u l=0.13u ng=1 m=1 mm_ok=1
XMP0 net3 net3 PTVDD PTVDD sg13_lv_pmos w=0.3u l=0.13u ng=1 m=1 mm_ok=1
.ends


* expanding   symbol:  inverting_digital_level_translator.sym # of pins=5
** sym_path: xschem/inverting_digital_level_translator.sym
** sch_path: xschem/inverting_digital_level_translator.sch
.subckt inverting_digital_level_translator PLAVDD PLDVDD LIN nLOUT PLVSS
*.iopin PLAVDD
*.iopin PLVSS
*.iopin PLDVDD
*.ipin LIN
*.opin nLOUT
XM1 n_lin_buf net1 PLVSS PLVSS sg13_lv_nmos w=0.15u l=0.13u ng=1 m=1 mm_ok=1
XM2 n_lin_buf net1 PLDVDD PLDVDD sg13_lv_pmos w=0.3u l=0.13u ng=1 m=1 mm_ok=1
XM3 lin_buf n_lin_buf PLVSS PLVSS sg13_lv_nmos w=0.15u l=0.13u ng=1 m=1 mm_ok=1
XM4 lin_buf n_lin_buf PLDVDD PLDVDD sg13_lv_pmos w=0.3u l=0.13u ng=1 m=1 mm_ok=1
XM5 q_unbf n_lin_buf PLVSS PLVSS sg13_hv_nmos w=1u l=0.45u ng=1 m=1 mm_ok=1
XM6 n_q_unbf lin_buf PLVSS PLVSS sg13_hv_nmos w=1u l=0.45u ng=1 m=1 mm_ok=1
XM7 n_q_unbf q_unbf PLAVDD PLAVDD sg13_hv_pmos w=0.3u l=0.45u ng=1 m=1 mm_ok=1
XM9 nLOUT n_q_unbf PLVSS PLVSS sg13_hv_nmos w=0.3u l=0.45u ng=1 m=4 mm_ok=1
XM10 nLOUT n_q_unbf PLAVDD PLAVDD sg13_hv_pmos w=0.6u l=0.45u ng=1 m=4 mm_ok=1
XM8 q_unbf n_q_unbf PLAVDD PLAVDD sg13_hv_pmos w=0.3u l=0.45u ng=1 m=1 mm_ok=1
XM11 net1 LIN PLVSS PLVSS sg13_lv_nmos w=0.15u l=0.13u ng=1 m=1 mm_ok=1
XM12 net1 LIN PLDVDD PLDVDD sg13_lv_pmos w=0.3u l=0.13u ng=1 m=1 mm_ok=1
.ends


* expanding   symbol:  digital_level_translator.sym # of pins=5
** sym_path: xschem/digital_level_translator.sym
** sch_path: xschem/digital_level_translator.sch
.subckt digital_level_translator PLAVDD PLDVDD LIN LOUT PLVSS
*.iopin PLAVDD
*.iopin PLVSS
*.iopin PLDVDD
*.ipin LIN
*.opin LOUT
XM1 n_lin_buf LIN PLVSS PLVSS sg13_lv_nmos w=0.15u l=0.13u ng=1 m=1 mm_ok=1
XM2 n_lin_buf LIN PLDVDD PLDVDD sg13_lv_pmos w=0.3u l=0.13u ng=1 m=1 mm_ok=1
XM3 lin_buf n_lin_buf PLVSS PLVSS sg13_lv_nmos w=0.15u l=0.13u ng=1 m=1 mm_ok=1
XM4 lin_buf n_lin_buf PLDVDD PLDVDD sg13_lv_pmos w=0.3u l=0.13u ng=1 m=1 mm_ok=1
XM5 q_unbf n_lin_buf PLVSS PLVSS sg13_hv_nmos w=1u l=0.45u ng=1 m=1 mm_ok=1
XM6 n_q_unbf lin_buf PLVSS PLVSS sg13_hv_nmos w=1u l=0.45u ng=1 m=1 mm_ok=1
XM7 n_q_unbf q_unbf PLAVDD PLAVDD sg13_hv_pmos w=0.3u l=0.45u ng=1 m=1 mm_ok=1
XM9 LOUT n_q_unbf PLVSS PLVSS sg13_hv_nmos w=0.3u l=0.45u ng=1 m=4 mm_ok=1
XM10 LOUT n_q_unbf PLAVDD PLAVDD sg13_hv_pmos w=0.6u l=0.45u ng=1 m=4 mm_ok=1
XM8 q_unbf n_q_unbf PLAVDD PLAVDD sg13_hv_pmos w=0.3u l=0.45u ng=1 m=1 mm_ok=1
.ends


* expanding   symbol:  down_digital_translator.sym # of pins=4
** sym_path: xschem/down_digital_translator.sym
** sch_path: xschem/down_digital_translator.sch
.subckt down_digital_translator PDIGVDD DIN DOUT PDIGVSS
*.iopin PDIGVDD
*.ipin DIN
*.opin DOUT
*.iopin PDIGVSS
XM1 net1 DIN PDIGVSS PDIGVSS sg13_hv_nmos w=0.3u l=0.45u ng=1 m=1 mm_ok=1
XM2 net1 DIN PDIGVDD PDIGVDD sg13_hv_pmos w=0.6u l=0.45u ng=1 m=1 mm_ok=1
XM3 DOUT net1 PDIGVSS PDIGVSS sg13_hv_nmos w=0.3u l=0.45u ng=1 m=1 mm_ok=1
XM4 DOUT net1 PDIGVDD PDIGVDD sg13_hv_pmos w=0.6u l=0.45u ng=1 m=1 mm_ok=1
.ends

.GLOBAL GND
.end
